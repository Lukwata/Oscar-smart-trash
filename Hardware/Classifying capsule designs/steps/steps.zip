Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: webcam_box.IFC
Time: 2018-07-09T07:25:42
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: webcam_box
In: Default Storey
Material: Steel
